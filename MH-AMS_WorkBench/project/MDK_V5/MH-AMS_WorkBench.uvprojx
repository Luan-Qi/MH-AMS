# Keil uVision project MH-AMS_WorkBench.uvprojx, settings and files
target MH-AMS_WorkBench (6180000::V6.18::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.1.7
  cpu: IRAM(0x20000000,0x1000000) IROM(0x08000000,0x4000000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: DP-AMS_WorkBench +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER,AT_START_F421_V1
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\middlewares\dp_ams;..\..\middlewares\CRC\src;..\..\middlewares\Arduino;..\..\middlewares\AS5600;..\..\middlewares\i2c_application_library;..\..\middlewares\PID;..\..\middlewares\letter_shell\src;..\..\middlewares\letter_shell\extensions\cpp_support
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group user
    ../src/: at32f421_int.c at32f421_wk_config.c main.c delay.c flash.c button.c
  group firmware
    ../../libraries/drivers/src/: at32f421_crm.c at32f421_tmr.c at32f421_gpio.c at32f421_usart.c at32f421_pwc.c at32f421_dma.c at32f421_debug.c at32f421_flash.c at32f421_misc.c at32f421_scfg.c at32f421_i2c.c
  group cmsis
    ../../libraries/cmsis/cm4/device_support/: system_at32f421.c
    ./: startup_at32f421.s
  group lib
    ../../middlewares/CRC/src/: CRC8.cpp CRC16.cpp CrcFastReverse.cpp
    ../../middlewares/AS5600/: MyiiC.cpp AS5600.cpp
    ../../middlewares/PID/: pid.c
  group src
    ../../middlewares/dp_ams/: MH_MCU.cpp BambuBus.cpp FIFO_buffer.c beep.c motor.c time32.cpp USB_debug.c
  group shell
    ../../middlewares/letter_shell/src/: shell.c shell_cmd_list.c shell_companion.c shell_ext.c
